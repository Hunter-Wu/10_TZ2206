# IAR project uart_int.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: __DEBUG
  ICCARM.CCIncludePath2: E:\work\10_TZ2206\software\project\driver\inc; E:\work\10_TZ2206\software\project\common; E:\work\10_TZ2206\software\project\bsp; E:\work\10_TZ2206\software\project\source
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: uart_int.hex
  ILINK.IlinkOutputFile: uart_int.out
  ILINK.IlinkIcfFile: HC32F005.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration debug (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\..\..\..\mcu\common; ..\source; ..\..\..\..\driver\inc; ..\..\..\..\utility
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: uart_int.srec
  group common
    ../common/: interrupts_hc32f005.c system_hc32f005.c
  group driver
    ../driver/src/: adc.c bgr.c bt.c ddl.c gpio.c lpm.c pca.c sysctrl.c uart.c
  group README
    ../: readme.txt
  group source
    ../source/: main.c
