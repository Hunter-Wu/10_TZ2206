<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\..\..\..\..\new\EWARM\tz_project.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\uart_int.ewp</path>
    </project>
    <batchBuild />
</workspace>
