# Keil uVision project template.uvprojx, settings and files
target template_Release (6130001::V6.13.1::.\ARMCLANG)
  device: HC32F005C6PA HDSC
  pack: HDSC.HC32F005.1.0.1
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 wLevel=4
  c include: ..\source;..\driver\src;..\driver\inc;..\common;..\bsp\bsp_adc;..\bsp\bsp_uart;..\bsp\key;..\bsp\ld_pwm;..\bsp\led;..\bsp\bsp_current_signal;..\bsp\bsp_output_signal;..\bsp\data_save;..\bsp\bsp_timer
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --keep=*Handler
  group source
    ../source/: main.c
  group bsp
    ../bsp/bsp_adc/: bsp_adc.c
    ../bsp/bsp_uart/: bsp_uart.c
    ../bsp/key/: key.c
    ../bsp/ld_pwm/: ld_pwm.c
    ../bsp/led/: led.c
    ../bsp/bsp_current_signal/: bsp_current_signal.c
    ../bsp/bsp_output_signal/: bsp_output_signal.c
    ../bsp/data_save/: data_save.c
    ../bsp/bsp_timer/: bsp_timer.c
  group driver
    ../driver/src/: ddl.c sysctrl.c adc.c bgr.c bt.c gpio.c lpm.c pca.c uart.c flash.c
  group common
    ./: startup_hc32f005.s
    ../common/: system_hc32f005.c interrupts_hc32f005.c
  group README
    ../: readme.txt
software components: CMSIS:CORE 5.0.2
